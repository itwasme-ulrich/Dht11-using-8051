# Keil uVision project 8051_DHT11_Project_File.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: 8051_DHT11_Project_File +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD16x2_4bit.c
